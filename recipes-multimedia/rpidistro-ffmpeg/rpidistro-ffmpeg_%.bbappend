# allow ffmpeg to use x264
PACKAGECONFIG:append = " x264"
