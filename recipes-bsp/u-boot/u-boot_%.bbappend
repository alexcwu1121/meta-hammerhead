FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://hammerhead_defconfig"