SUMMARY = "Hammerhead core development image"
LICENSE = "MIT"

inherit hammerhead-core-image
