SUMMARY = "Hammerhead core image"
LICENSE = "MIT"

require recipes-core/images/hammerhead-core-image.inc
